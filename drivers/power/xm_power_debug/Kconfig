## drivers/power/xm_power_debug/Kconfig
```kconfig
config XM_POWER_DEBUG
	bool "XM Power Debug Feature"
	default y
	help
	  XM Power Debug Feature
```
